options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Sniffer_stream
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '"127.0.0.1:5066"'
  states: {}
- name: port
  id: variable
  parameters:
    value: '50001'
  states: {}
- name: ainfosec_UDP_to_Wireshark_0
  id: ainfosec_UDP_to_Wireshark
  parameters:
    port: int(port)
  states: {}
- name: ainfosec_UDP_to_Wireshark_Async_0
  id: ainfosec_UDP_to_Wireshark_Async
  parameters:
    port: port
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '250000'
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: '"tcp://" + address'
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://" + address'
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_tagged_stream_align_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', ainfosec_UDP_to_Wireshark_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, ainfosec_UDP_to_Wireshark_Async_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [zeromq_sub_msg_source_0, out, ainfosec_UDP_to_Wireshark_Async_0, in]
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_source_0_0, '0', blocks_tagged_stream_align_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
