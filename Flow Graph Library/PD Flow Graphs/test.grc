options:
  parameters:
    category: Custom
    description: Generic demodulation flow graph for MSK signals.
    generate_options: no_gui
    id: test
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '"*:5066"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: max_burst_size
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: min_burst_size
  id: variable
  parameters:
    value: '100'
  states: {}
- name: nbits_prior
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 2425.729695e6
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: signal_type
  id: variable
  parameters:
    value: '"MSK"'
  states: {}
- name: sync_code
  id: variable
  parameters:
    value: '"11010011100100011101001110010001"'
  states: {state: disabled}
- name: time_out
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    bw0: sample_rate
    center_freq0: rx_frequency
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
