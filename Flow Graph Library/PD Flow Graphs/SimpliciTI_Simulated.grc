options:
  parameters:
    category: Custom
    description: Captured SimpliciTI data is repeated from a file source.
    generate_options: no_gui
    id: SimpliciTI_Simulated
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e7
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/FISSURE/Crafted Packets/simpliciti_data.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5066
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
