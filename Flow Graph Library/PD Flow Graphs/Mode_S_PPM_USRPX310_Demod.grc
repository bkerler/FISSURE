options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_USRPX310_Demod
    output_language: python
    run_options: run
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '33'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.010'
  states: {}
- name: zmq_port
  id: variable
  parameters:
    value: '5066'
  states: {}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"All Messages"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: samp_rate
    threshold: threshold
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: filerepeater_msg_to_file_0
  id: filerepeater_msg_to_file
  parameters:
    file: /dev/stdout
    overwrite: 'False'
    timestamp: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: gain
    samp_rate: samp_rate
    sd_spec0: channel
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: '"tcp://*:" + str(zmq_port)'
    timeout: '100'
  states: {}

connections:
- [adsb_decoder_0_0, decoded, filerepeater_msg_to_file_0, msg]
- [adsb_decoder_0_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', blocks_null_sink_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', adsb_framer_1, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
