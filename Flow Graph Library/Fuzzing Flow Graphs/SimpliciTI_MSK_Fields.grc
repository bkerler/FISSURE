options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: SimpliciTI_MSK_Fields
    output_language: python
  states: {}

blocks:
- name: data
  id: variable
  parameters:
    value: 0xAA,0xAA,0xAA,0xAA,0xD3,0x91,0xD3,0x91,0x0E,0x78,0x56,0x34,0x12,0xAA,0xAA,0xAA,0xAA,0x20,0x03,0x33,0xAA,0x00,0xFF,0xE4,0x0D
  states: {state: disabled}
- name: data1
  id: variable
  parameters:
    value: 0xAA,0xAA,0xAA,0xAA,0xD3,0x91,0xD3,0x91,0x0E,0x78,0x56,0x34,0x12,0xAA,0xAA,0xAA,0xAA,0x20,0x03,0x33,0xAA,0x40,0xFF,0x64,0x0B
  states: {state: disabled}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Temperature LSB'',''Voltage'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"1"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''255'',''255'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'',''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"ED-Data"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"SimpliciTI"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'',''Sequential'']"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: library_filepath
  id: variable
  parameters:
    value: '"~/FISSURE/YAML/library.yaml"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2425.6e6
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '4'
    sensitivity: '0.2'
  states: {}
- name: fuzzer_fuzzer_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    library_filepath: library_filepath
  states: {}
- name: fuzzer_packet_insert_0
  id: fuzzer_packet_insert
  parameters:
    offset: '0'
    period: '20'
    vector: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    clock_source0: internal
    dev_args: '"addr=" + ip_address'
    gain0: '30'
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_not_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_mute_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_mute_xx_0, set_mute]
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_mute_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_not_xx_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_null_source_0, '0', fuzzer_packet_insert_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_1, '0']
- [fuzzer_fuzzer_0, packet_out, fuzzer_packet_insert_0, packet_in]
- [fuzzer_packet_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [fuzzer_packet_insert_0, set_mute, blocks_mute_xx_0, set_mute]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
