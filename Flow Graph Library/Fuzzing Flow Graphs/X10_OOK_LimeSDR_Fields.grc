options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: X10_OOK_LimeSDR_Fields
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x00"'
  states: {}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Address Code'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"5"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''65535'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"Default"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"X10"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'']"'
  states: {}
- name: library_filepath
  id: variable
  parameters:
    value: '"~/FISSURE/YAML/library.yaml"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {}
- name: transmit_interval
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: X10_msg_gen_fuzzer_0
  id: X10_msg_gen_fuzzer
  parameters:
    address_code: address_code
    data_code: data_code
    press_duration: transmit_interval/2
    press_repetition_interval: transmit_interval
    sample_rate: sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: fuzzer_fuzzer_0_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    library_filepath: library_filepath
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}

connections:
- [X10_msg_gen_fuzzer_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_null_source_0, '0', X10_msg_gen_fuzzer_0, '0']
- [fuzzer_fuzzer_0_0, packet_out, X10_msg_gen_fuzzer_0, fuzzer_in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
