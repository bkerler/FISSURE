options:
  parameters:
    category: RDS
    generate_options: no_gui
    id: RDS_BPSK_HackRF_Fields
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Crafted Packets/rdsA2.bin"'
  states: {state: disabled}
- name: fm_max_dev
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 106.5e6
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '106500000'
  states: {}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Country Code'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"1"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''15'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"Message Version A"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"RDS"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'']"'
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: '.3'
  states: {}
- name: library_filepath
  id: variable
  parameters:
    value: '"~/FISSURE/YAML/library.yaml"'
  states: {}
- name: lower_rate
  id: variable
  parameters:
    value: '380000'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '.3'
  states: {}
- name: ps
  id: variable
  parameters:
    value: '"WDR 3"'
  states: {state: disabled}
- name: rds_gain
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: stereo_gain
  id: variable
  parameters:
    value: '.3'
  states: {}
- name: transmit_interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {state: disabled}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse_monitor
    num_outputs: '2'
    samp_rate: '44100'
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: input_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_gain
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pilot_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: input_gain
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    maxoutbuf: outbuffer
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '160'
    type: float
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '10000000000'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_1
  id: blocks_skiphead
  parameters:
    num_items: 104*2000000000
    type: byte
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1e6
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: 380000/160/8/4
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (99, 147, 114, 129, 114, 161, 206, 17, 122, 136, 204, 130, 179)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: simpsons.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: fuzzer_continuous_insert_0
  id: fuzzer_continuous_insert
  parameters:
    vector: (99, 147, 114, 129, 114, 161, 206, 17, 122, 136, 204, 130, 179)
  states: {}
- name: fuzzer_fuzzer_0_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    library_filepath: library_filepath
  states: {}
- name: fuzzer_packet_insert_0
  id: fuzzer_packet_insert
  parameters:
    offset: '0'
    period: int(380000*transmit_interval/8)
    vector: '0'
  states: {state: disabled}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    num_inputs: '4'
    type: float
  states: {state: disabled}
- name: gr_add_xx_1_0
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {state: disabled}
- name: gr_char_to_float_0
  id: blocks_char_to_float
  parameters:
    maxoutbuf: outbuffer
    scale: '1'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/lower_rate
  states: {}
- name: gr_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: gr_rds_encoder_0
  id: gr_rds_encoder
  parameters:
    af1: 89.8e6
    maxoutbuf: outbuffer
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: ps
    pty: '14'
    pty_locale: '1'
    radiotext: Happy Birthday Karen
    ta: 'False'
    tp: 'True'
  states: {state: disabled}
- name: gr_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: lower_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: input_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '10'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.3'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e3
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: lower_rate
    type: interp_fir_filter_fff
    width: .5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '.00625'
    type: float
  states: {}
- name: mmse_resampler_xx_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (lower_rate/10000)/100.0
    type: complex
  states: {}
- name: mmse_resampler_xx_2
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 44.1/(usrp_rate/1000)
    type: float
  states: {state: disabled}
- name: mmse_resampler_xx_2_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 44.1/(usrp_rate/1000)
    type: float
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=" + str(serial)'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    if_gain0: '30'
    sample_rate: 1e6
    sync: sync
    type: fc32
  states: {}
- name: pilot_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.3'
  states: {state: disabled}
- name: ps
  id: variable_text_box
  parameters:
    converver: str_converter
    formatter: None
    label: PS
    value: '"WDR 3"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '104'
    srate: '1'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '100'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '19'
    interp: '50'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rds_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.5'
  states: {state: disabled}
- name: stereo_gain
  id: variable_slider
  parameters:
    converver: float_converter
    label: ''
    max: '3'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.3'
  states: {state: disabled}
- name: uhd_usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: '"ip_addr=192.168.40.2"'
    dev_args: '""'
    gain0: '30'
    len_tag_name: ''
    samp_rate: 1e6
    sd_spec0: '"A:0"'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_usrp_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: 1e6
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {state: disabled}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '30'
    fft_size: '1024'
    freqvar: None
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: usrp_rate
    title: FFT Plot
    type: float
    win: None
    y_divs: '10'
    y_per_div: '20'
  states: {state: disabled}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_2_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', gr_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', gr_add_xx_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', gr_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', gr_add_xx_1, '1']
- [blocks_multiply_const_vxx_0_0_1, '0', gr_add_xx_1_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', mmse_resampler_xx_2, '0']
- [blocks_multiply_const_vxx_0_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_null_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_null_source_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_null_source_0_0, '0', blocks_skiphead_1, '0']
- [blocks_null_source_0_0, '0', fuzzer_continuous_insert_0, '0']
- [blocks_null_source_0_0, '0', fuzzer_packet_insert_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_skiphead_0, '0', uhd_usrp_sink_0, '0']
- [blocks_skiphead_1, '0', fuzzer_continuous_insert_0, '0']
- [blocks_socket_pdu_0, pdus, gr_rds_encoder_0, rds in]
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', gr_diff_encoder_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [fuzzer_continuous_insert_0, '0', blocks_throttle_1, '0']
- [fuzzer_continuous_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [fuzzer_fuzzer_0_0, packet_out, blocks_message_debug_0, print]
- [fuzzer_fuzzer_0_0, packet_out, fuzzer_continuous_insert_0, packet_in]
- [fuzzer_fuzzer_0_0, packet_out, fuzzer_packet_insert_0, packet_in]
- [fuzzer_packet_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [gr_add_xx_0, '0', gr_add_xx_1, '3']
- [gr_add_xx_0, '0', low_pass_filter_0_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_add_xx_1, '0', wxgui_fftsink2_0, '0']
- [gr_add_xx_1_0, '0', gr_frequency_modulator_fc_0, '0']
- [gr_char_to_float_0, '0', blocks_repeat_0, '0']
- [gr_char_to_float_0, '0', mmse_resampler_xx_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_frequency_modulator_fc_0, '0', mmse_resampler_xx_1, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_map_bb_0, '0', gr_char_to_float_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '2']
- [gr_rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [gr_sig_source_x_0, '0', gr_multiply_xx_1, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_sig_source_x_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [gr_sub_xx_0, '0', gr_multiply_xx_1, '1']
- [gr_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [gr_unpack_k_bits_bb_0, '0', gr_map_bb_0, '0']
- [low_pass_filter_0, '0', gr_multiply_xx_0, '1']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '3']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '1']
- [mmse_resampler_xx_0, '0', low_pass_filter_0, '0']
- [mmse_resampler_xx_1, '0', blocks_throttle_0, '0']
- [mmse_resampler_xx_1, '0', osmosdr_sink_0, '0']
- [mmse_resampler_xx_1, '0', uhd_usrp_sink_0, '0']
- [mmse_resampler_xx_2, '0', gr_add_xx_0, '1']
- [mmse_resampler_xx_2, '0', gr_sub_xx_0, '1']
- [mmse_resampler_xx_2_0, '0', gr_add_xx_0, '0']
- [mmse_resampler_xx_2_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', gr_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', gr_sub_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_1_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
