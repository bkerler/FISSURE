options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Garage_Door_OOK_USRPB205mini_Cycle
    output_language: python
  states: {}

blocks:
- name: burst_interval
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: bursts_per_dip
  id: variable
  parameters:
    value: '5'
  states: {}
- name: dip_interval
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Cycles through DIP switch combinations sequentially."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: starting_dip
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: tx_usrp_frequency
  id: variable
  parameters:
    value: 310.4e6
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: disabled}
- name: garage_door_message_cycler_0
  id: garage_door_message_cycler
  parameters:
    bpd: bursts_per_dip
    burst_interval: burst_interval
    dip_interval: dip_interval
    sample_rate: sample_rate
    starting_dip: starting_dip
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '10000'
    srate: sample_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_usrp_frequency
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', garage_door_message_cycler_0, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_0, '0']
- [garage_door_message_cycler_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
