options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: SimpliciTI_FSK_LimeSDR_From_File
    output_language: python
  states: {}

blocks:
- name: data_rate
  id: variable
  parameters:
    value: '2398.9677429'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/SimpliciTI_Add_Node2.bin"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Replays message data supplied from a file."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sampling_factor
  id: variable
  parameters:
    value: '100'
  states: {}
- name: sampling_multiple
  id: variable
  parameters:
    value: '16'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2425.715e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '200'
    sensitivity: '0.1'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: sampling_factor*data_rate*sampling_multiple/sample_rate
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', limesdr_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
