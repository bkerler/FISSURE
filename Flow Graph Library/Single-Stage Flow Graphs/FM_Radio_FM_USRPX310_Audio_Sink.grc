options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_FM_USRPX310_Audio_Sink
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 102.5e6
  states: {}
- name: frequency_offset
  id: variable
  parameters:
    value: 0.3e6
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Plays the audio for FM radio stations."'
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"B:0"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_offset
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '10'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: frequency+frequency_offset
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: usrp_gain
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
