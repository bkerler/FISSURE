options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_Simple_Replay
    output_language: python
  states: {}

blocks:
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Relays a DECT signal to another frequency."'
  states: {}
- name: rx_freq_1
  id: variable
  parameters:
    value: 1921.536e6
  states: {state: disabled}
- name: rx_freq_2
  id: variable
  parameters:
    value: 1923.264e6
  states: {state: disabled}
- name: rx_freq_3
  id: variable
  parameters:
    value: 1924.992e6
  states: {state: disabled}
- name: rx_freq_4
  id: variable
  parameters:
    value: 1926.720e6
  states: {state: disabled}
- name: rx_freq_5
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1928.448e6
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: squelch_value
  id: variable
  parameters:
    value: '-23'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 1921.536e6
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '100'
    threshold: squelch_value
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
