options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Wifi_Default_USRPX310_Relay
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {state: disabled}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Relays Wifi signals from one frequency to another."'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 5175e6
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '70'
  states: {}
- name: usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,10,4
    label1: ''
    label2: ''
    size: '100000'
    srate: sample_rate/decimation
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: rx_usrp_gain
    samp_rate: sample_rate
    sd_spec0: usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
