options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Garage_Door_OOK_LimeSDR_Transmit
    output_language: python
  states: {}

blocks:
- name: dip_positions
  id: variable
  parameters:
    value: '"1010101010"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Simulates a remote control button press for one DIP switch value."'
  states: {}
- name: press_duration
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: press_repetition_interval
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["dip_positions"]'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 310.4e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: disabled}
- name: garage_door_message_generator_0
  id: garage_door_message_generator
  parameters:
    dip_positions: dip_positions
    press_duration: press_duration
    press_repetition_interval: press_repetition_interval
    sample_rate: sample_rate
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1000000'
    srate: sample_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_null_source_0, '0', garage_door_message_generator_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [garage_door_message_generator_0, '0', blocks_multiply_const_vxx_0, '0']
- [garage_door_message_generator_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
