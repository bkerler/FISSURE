options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Garage_Door_OOK_LimeSDR_Cycle
    output_language: python
  states: {}

blocks:
- name: burst_interval
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: bursts_per_dip
  id: variable
  parameters:
    value: '5'
  states: {}
- name: dip_interval
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Cycles through DIP switch combinations sequentially."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: starting_dip
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 310.4e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: disabled}
- name: garage_door_message_cycler_0
  id: garage_door_message_cycler
  parameters:
    bpd: bursts_per_dip
    burst_interval: burst_interval
    dip_interval: dip_interval
    sample_rate: sample_rate
    starting_dip: starting_dip
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '10000'
    srate: sample_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_null_source_0, '0', garage_door_message_cycler_0, '0']
- [blocks_throttle_0, '0', blocks_keep_one_in_n_0, '0']
- [garage_door_message_cycler_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
