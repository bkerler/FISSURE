options:
  parameters:
    generate_options: no_gui
    id: ZWAVE_FSK_LimeSDR_ColorList
    output_language: python
  states: {}

blocks:
- name: command
  id: variable
  parameters:
    value: '"0163"'
  states: {state: disabled}
- name: command_class
  id: variable
  parameters:
    value: '"26"'
  states: {state: disabled}
- name: configuration
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: destination_node_id
  id: variable
  parameters:
    value: '"02"'
  states: {}
- name: frame_control
  id: variable
  parameters:
    value: '"4108"'
  states: {}
- name: home_id
  id: variable
  parameters:
    value: '"fa1c0b48"'
  states: {}
- name: msg_length
  id: variable
  parameters:
    comment: Home ID through CRC
    value: '24'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Cycles through a list of colors built into the message_generator_pdu block. Tested against a Monoprice Z-Wave Plus RGB Smart Bulb."'
  states: {}
- name: repetition_interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: source_node_id
  id: variable
  parameters:
    value: '"01"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["home_id","source_node_id","frame_control","destination_node_id"]'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 916e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*80000/8.0)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: on/off
    delay: (10*8*(26+14+4))-24
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: colors
    delay: (10*8*(26+msg_length+4))-24
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2*10*8*(26+msg_length+4)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: on/off
    len_tag_key: '"packet_len"'
    packet_len: 10*8*(26+14+4)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: colors
    len_tag_key: '"packet_len"'
    packet_len: 10*8*(26+msg_length+4)
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.65'
    samples_per_symbol: '10'
    sensitivity: '0.25'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    length_tag_name: packet_len
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: samp_rate
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '20000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: '20000'
    srate: '1'
    type: complex
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: command
    command_class: command_class
    comment: 'on'
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: frame_control
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0100"'
    command_class: '"26"'
    comment: 'off'
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"050500000100020003ff0400"'
    command_class: '"33"'
    comment: green
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000240039c0400"'
    command_class: '"33"'
    comment: color_list
    configuration: '2'
    destination_node_id: destination_node_id
    frame_control: frame_control
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000240039c0400"'
    command_class: '"33"'
    comment: random
    configuration: '3'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_0_0_0_1
  id: zwave_poore_message_generator_pdu
  parameters:
    command: '"0505000001000200030004ff"'
    command_class: '"33"'
    comment: green
    configuration: '1'
    destination_node_id: '"02"'
    frame_control: '"4108"'
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}
- name: zwave_poore_message_generator_pdu_0_0_0_1
  id: zwave_poore_message_generator_pdu
  parameters:
    command: command
    command_class: command_class
    comment: red
    configuration: '1'
    destination_node_id: destination_node_id
    frame_control: frame_control
    home_id: home_id
    repetition_interval: repetition_interval
    source_node_id: source_node_id
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_head_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', limesdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [zwave_poore_message_generator_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_0_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_0_0_0_1, out, pdu_pdu_to_tagged_stream_0, pdus]
- [zwave_poore_message_generator_pdu_0_0_0_1, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
