options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_FM_LimeSDR_File_Sink
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: delay_length
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: frequency_offset
  id: variable
  parameters:
    value: 0.3e6
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Records a set amount of FM data to a file while playing the audio."'
  states: {}
- name: recording_length
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: rx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 102.5e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_offset
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    deemph_tau: '75e-6'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay_length)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(recording_length)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(rx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_gain)
    gain_dB_ch1: int(rx_gain)
    oversample: '0'
    rf_freq: rx_frequency
    samp_rate: sample_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '10'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', audio_sink_0, '0']
- [blocks_delay_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_head_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
