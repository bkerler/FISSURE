options:
  parameters:
    generate_options: no_gui
    id: TPMS_FSK_LimeSDR_Transmit
    output_language: python
  states: {}

blocks:
- name: battery_status
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: configuration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '"00"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits TPMS signals periodically."'
  states: {}
- name: repetition_interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: self_test
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: sensor_id
  id: variable
  parameters:
    value: '"528A510"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["sensor_id","battery_status","counter","unknown1","unknown2","self_test"]'
  states: {}
- name: tire_pressure_psi
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tire_temperature_c
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 314.96e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: unknown1
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: unknown2
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*80000/8.0)
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*80000/8.0)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '15800'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 100*8*20
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.65'
    samples_per_symbol: '100'
    sensitivity: '0.25'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 4*[0.25]
    type: fff
  states: {state: disabled}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: samp_rate
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '2048'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '40000'
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '40000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '80000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: '80000'
    srate: '1'
    type: complex
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: tpms_poore_message_generator_pdu_0
  id: tpms_poore_message_generator_pdu
  parameters:
    battery_status: battery_status
    configuration: configuration
    counter: counter
    repetition_interval: repetition_interval
    self_test: self_test
    sensor_id: sensor_id
    tire_pressure: tire_pressure_psi
    tire_temp: tire_temperature_c
    unknown1: unknown1
    unknown2: unknown2
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', limesdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [tpms_poore_message_generator_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
