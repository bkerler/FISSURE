options:
  parameters:
    generate_options: no_gui
    id: Morse_Code_OOK_USRPB205mini_File
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 144e6
    step: '1000'
    stop: 148e6
    value: 144.95e6
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 144.95e6
  states: {state: disabled}
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '300'
    step: '100'
    stop: '2000'
    value: '800'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '800'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Generates Morse Code for one user-provided message and writes the IQ samples to file. The audio will stop when the message is complete."'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '4430'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: speed
  id: variable
  parameters:
    value: '13'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '300'
  states: {}
- name: text
  id: variable
  parameters:
    value: '"Hello World!"'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: volume
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {state: disabled}
- name: volume
  id: variable
  parameters:
    value: '.05'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Morse code vector source
      """

      #  epy_block_0.py
      #  revised 09/10/2019 - finish code table
      #  revised 09/11/2019 - test for bad character
      #  revised 09/27/2019 - get input from a Message Edit block (code from Volker Schroer dl1ksv)

      import numpy as np
      from gnuradio import gr

      import pmt

      textboxValue = ""

      Morse = {
        # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en
          "A": "1,0,1,1,1",
          "B": "1,1,1,0,1,0,1,0,1",
          "C": "1,1,1,0,1,0,1,1,1,0,1",
          "D": "1,1,1,0,1,0,1",
          "E": "1",
          "F": "1,0,1,0,1,1,1,0,1",
          "G": "1,1,1,0,1,1,1,0,1",
          "H": "1,0,1,0,1,0,1",
          "I": "1,0,1",
          "J": "1,0,1,1,1,0,1,1,1,0,1,1,1",
          "K": "1,1,1,0,1,0,1,1,1",
          "L": "1,0,1,1,1,0,1,0,1",
          "M": "1,1,1,0,1,1,1",
          "N": "1,1,1,0,1",
          "O": "1,1,1,0,1,1,1,0,1,1,1",
          "P": "1,0,1,1,1,0,1,1,1,0,1",
          "Q": "1,1,1,0,1,1,1,0,1,0,1,1,1",
          "R": "1,0,1,1,1,0,1",
          "S": "1,0,1,0,1",
          "T": "1,1,1",
          "U": "1,0,1,0,1,1,1",
          "V": "1,0,1,0,1,0,1,1,1",
          "W": "1,0,1,1,1,0,1,1,1",
          "X": "1,1,1,0,1,0,1,0,1,1,1",
          "Y": "1,1,1,0,1,0,1,1,1,0,1,1,1",
          "Z": "1,1,1,0,1,1,1,0,1,0,1",
          " ": "0",            # space
          "1": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "2": "1,0,1,0,1,1,1,0,1,1,1,0,1,1,1",
          "3": "1,0,1,0,1,0,1,1,1,0,1,1,1",
          "4": "1,0,1,0,1,0,1,0,1,1,1",
          "5": "1,0,1,0,1,0,1,0,1",
          "6": "1,1,1,0,1,0,1,0,1,0,1",
          "7": "1,1,1,0,1,1,1,0,1,0,1,0,1",
          "8": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1",
          "9": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",
          "0": "1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1",
          ".": "1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1",          # period
          ",": "1,1,1,0,1,1,1,0,1,0,1,0,1,1,1,0,1,1,1",      # comma
          ":": "1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1",          # colon
          "?": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1",              # question
          "'": "1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1",      # apostrophe
          "-": "1,1,1,0,1,0,1,0,1,0,1,0,1,1,1",              # dash or minus
          "/": "1,1,1,0,1,0,1,0,1,1,1,0,1",                  # slash
          "(": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1",              # left parenthesis
          ")": "1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",      # right parenthesis
          "\"": "1,0,1,1,1,0,1,0,1,0,1,1,1,0,1",             # quote
          "=": "1,1,1,0,1,0,1,0,1,0,1,1,1",                  # equals
          "+": "1,0,1,1,1,0,1,0,1,1,1,0,1",                  # plus
          "@": "1,0,1,1,1,0,1,1,1,0,1,0,1,1,1,0,1",          # at sign (@)
        # these punctuation marks are not included in the ITU recommendation,
        # but are found in https://en.wikipedia.org/wiki/Morse_code
          "!": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,1",      # exclamation point
          "&": "1,0,1,1,1,0,1,0,1,0,1",                      # ampersand (also prosign for 'WAIT')
          ";": "1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1",          # semicolon
          "_": "1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1",          # underscore
          "$": "1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,1,1"           # dollar sign
            }

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Morse code bits
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Morse code vector source",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue
              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global Morse
              global textboxValue
              bit_stream = ""
              if (len (textboxValue) > 0):
                  for in0 in textboxValue:
                      # get next char
                      inChar = str (in0)
                      # convert to upper case
                      ch = inChar.upper()
                      # test for character in table
                      if (not(ch in Morse)):
                      # print ("bad char", ch)
                          ch = "?"        # replace bad character with a '?'
                      # build vector
                      _dots = str (Morse.get(ch))
                      # print (ch, _dots)
                      bit_stream += (_dots + ",0,0,0,")    # letter space

                  bit_stream += "0,0,0,0"    # finish with word space
                  # print (bit_stream)

                  # get length of string
                  _len = len(bit_stream)
                  # num of elements = (length+1) / 2
                  _num_elem = int((_len+1) / 2)

                  # convert and store elements in output array
                  for x in range (_len):
                      y = int(x / 2)
                      if (bit_stream[x] == '1'):
                          output_items[0][y] = 1
                      elif (bit_stream[x] == '0'):
                          output_items[0][y] = 0
                      else:
                          continue    # skip commas

                  # clear input line
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              else:
                  _num_elem = 0

              return (_num_elem)
  states: {}
- name: foo_periodic_msg_source_0
  id: foo_periodic_msg_source
  parameters:
    debug: 'False'
    interval: '60000'
    msg: pmt.intern(str(text))
    num: '1'
    quit: 'True'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: sample_rate/audio_rate
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    label: Input
    type: string
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '2000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '8000'
    srate: '1'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_channel
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', mmse_resampler_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']
- [epy_block_0, clear_input, qtgui_edit_box_msg_0, val]
- [foo_periodic_msg_source_0, out, epy_block_0, msg_in]
- [mmse_resampler_xx_0, '0', blocks_file_sink_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [mmse_resampler_xx_0, '0', uhd_usrp_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_float_to_complex_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_keep_one_in_n_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
