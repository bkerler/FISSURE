options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: X10_OOK_USRPB205mini_X10_Off
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x20"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits an off message for a RadioShack Plug''n power outlet switch."'
  states: {}
- name: press_duration
  id: variable
  parameters:
    value: '4'
  states: {}
- name: press_repetition_interval
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: tx_usrp_frequency
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 309e6
    step: .1e6
    stop: 312e6
    value: 310.8e6
  states: {state: disabled}
- name: tx_usrp_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: X10_message_generator_0
  id: X10_message_generator
  parameters:
    address_code: address_code
    data_code: data_code
    press_duration: press_duration
    press_repetition_interval: press_repetition_interval
    sample_rate: sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_usrp_frequency
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [X10_message_generator_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', X10_message_generator_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
