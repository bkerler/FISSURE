options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Wifi_Default_LimeSDR_Relay
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '100'
  states: {state: disabled}
- name: notes
  id: variable
  parameters:
    value: '"Relays Wifi signals from one frequency to another."'
  states: {}
- name: rx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2432e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {state: disabled}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: tx_channel
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: rx_channel
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_gain)
    gain_dB_ch1: int(rx_gain)
    oversample: '0'
    rf_freq: rx_frequency
    samp_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 4,0,10,4
    label1: ''
    label2: ''
    size: '100000'
    srate: sample_rate/decimation
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {state: disabled}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [limesdr_source_0, '0', blocks_keep_one_in_n_0, '0']
- [limesdr_source_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
