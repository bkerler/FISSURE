options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Clapper_Plus_OOK_USRPB210_Transmit
    output_language: python
  states: {}

blocks:
- name: button2or3
  id: variable
  parameters:
    value: '2'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Generates a signal that is similar to one of two buttons on a Clapper Plus remote control."'
  states: {}
- name: press_repetition_interval
  id: variable
  parameters:
    comment: No idea why interval of 10 works every other time
    value: '5'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"False"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: tx_usrp_frequency
  id: variable
  parameters:
    comment: button 2
    value: 433.962e6
  states: {state: disabled}
- name: tx_usrp_frequency
  id: variable
  parameters:
    comment: button 3
    value: 433.97e6
  states: {state: disabled}
- name: tx_usrp_frequency
  id: variable
  parameters:
    value: 433.966e6
  states: {}
- name: tx_usrp_frequency_915
  id: variable
  parameters:
    value: 914.9849e6
  states: {state: disabled}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: clapper_plus_message_generator_433_0
  id: clapper_plus_message_generator_433
  parameters:
    button: button2or3
    press_repetition_interval: press_repetition_interval
    sample_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1500000'
    srate: sample_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_usrp_frequency
    clock_rate: '0.0'
    dev_addr: serial
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', clapper_plus_message_generator_433_0, '0']
- [clapper_plus_message_generator_433_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
