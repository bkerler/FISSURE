options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_FM_LimeSDR_CW
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 102.5e6
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Jams FM with a CW signal."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: frequency
    samp_rate: sample_rate
  states: {}

connections:
- [analog_sig_source_x_0, '0', limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
