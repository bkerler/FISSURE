options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: X10_OOK_LimeSDR_X10_Off
    output_language: python
  states: {}

blocks:
- name: address_code
  id: variable
  parameters:
    value: '"0x60"'
  states: {}
- name: data_code
  id: variable
  parameters:
    value: '"0x20"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits an off message for a RadioShack Plug''n power outlet switch."'
  states: {}
- name: press_duration
  id: variable
  parameters:
    value: '4'
  states: {}
- name: press_repetition_interval
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["address_code","data_code"]'
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 310.8e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: tx_usrp_frequency
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 309e6
    step: .1e6
    stop: 312e6
    value: 310.8e6
  states: {state: disabled}
- name: X10_message_generator_0
  id: X10_message_generator
  parameters:
    address_code: address_code
    data_code: data_code
    press_duration: press_duration
    press_repetition_interval: press_repetition_interval
    sample_rate: sample_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: int(tx_channel)
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}

connections:
- [X10_message_generator_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_null_source_0, '0', X10_message_generator_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
