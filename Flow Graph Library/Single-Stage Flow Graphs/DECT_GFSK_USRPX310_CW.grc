options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_CW
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 1921.536e6
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Jams DECT with a CW signal."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
