options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_File_Sink_IQ
    output_language: python
  states: {}

blocks:
- name: dect_symbol_rate
  id: variable
  parameters:
    value: 1.152e6
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/IQ Recordings/DECT - Avent Baby Monitor/file3"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Records DECT IQ signals captured through a power squelch to a file."'
  states: {}
- name: recording_length
  id: variable
  parameters:
    value: 388*2
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 1923.264e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1926.720e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1924.992e6
  states: {state: disabled}
- name: rx_frequency
  id: variable
  parameters:
    value: 1921.536e6
  states: {}
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3.456e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '100'
    threshold: '-42'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filepath
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '100000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '2048'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '100000'
    srate: sample_rate
    tr_level: '0.005'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    ymax: '0.3'
    ymin: '-0.3'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: rx_frequency
    clock_rate: '0.0'
    dev_addr: addr=192.168.40.2
    dev_args: '""'
    gain0: rx_usrp_gain
    samp_rate: sample_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_head_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
