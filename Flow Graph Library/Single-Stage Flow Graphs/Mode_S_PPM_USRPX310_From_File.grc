options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_USRPX310_From_File
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Crafted Packets/adsb_airborne_position_odd1.bin"'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits ADSB binary data supplied from a file."'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transmit_interval
  id: variable
  parameters:
    value: '.1'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: ainfosec_adsb_encode_0
  id: ainfosec_adsb_encode
  parameters:
    data_filepath: filepath
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.3'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: fuzzer_packet_insert_0
  id: fuzzer_packet_insert
  parameters:
    offset: '0'
    period: int(samp_rate*transmit_interval/8)
    vector: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_addr: '"addr = "+ip_address'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: samp_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [ainfosec_adsb_encode_0, out, fuzzer_packet_insert_0, packet_in]
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_null_source_0, '0', fuzzer_packet_insert_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [fuzzer_packet_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
