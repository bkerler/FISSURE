options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: Mode_S_PPM_HackRF_File_Sink
    output_language: python
    run_options: run
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Attack Recordings/adsb1.bin"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Decodes ADSB messages and prints the output to stdout and to a file."'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: adsb_decoder_0_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: samp_rate
  states: {}
- name: adsb_framer_0_0
  id: adsb_framer
  parameters:
    fs: 2e6
    threshold: '0.01'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.01'
    init: '0'
    low: '0.01'
  states: {}
- name: filerepeater_msg_to_file_0
  id: filerepeater_msg_to_file
  parameters:
    file: /dev/stdout
    overwrite: 'False'
    timestamp: 'False'
  states: {}
- name: filerepeater_msg_to_file_0_0
  id: filerepeater_msg_to_file
  parameters:
    file: filepath
    overwrite: 'False'
    timestamp: 'False'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=" + str(serial)'
    bb_gain0: '50'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '50'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [adsb_decoder_0_0, decoded, filerepeater_msg_to_file_0, msg]
- [adsb_decoder_0_0, decoded, filerepeater_msg_to_file_0_0, msg]
- [adsb_demod_0, '0', blocks_null_sink_1, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0_0, demodulated]
- [adsb_framer_0_0, '0', adsb_demod_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', adsb_framer_0_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
