options:
  parameters:
    generate_options: no_gui
    id: TPMS_FSK_LimeSDR_Receive
    output_language: python
  states: {}

blocks:
- name: notes
  id: variable
  parameters:
    value: '"Decodes TPMS signals (only one format) and prints the output."'
  states: {}
- name: rx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_frequency
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: rx_usrp_gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '90'
    value: '70'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0'
    max_gain: '20'
    rate: '0.05'
    reference: '1'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_burst_tagger_1
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '50'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/Desktop/newest_tpms_recordings/prius_front_left_bad5_cropped.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_1
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '20'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-4'
    init: '0'
    low: '-4'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 4*[0.25]
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 50*[0.02]
    type: fff
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_gain)
    gain_dB_ch1: int(rx_gain)
    oversample: '0'
    rf_freq: rx_frequency
    samp_rate: sample_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '40000'
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    size: '40000'
    srate: '1'
    type: float
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '5000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: tpms_poore_decoder_0
  id: tpms_poore_decoder
  parameters: {}
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_1, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [blocks_burst_tagger_1, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', fir_filter_xxx_1_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_1, '0']
- [blocks_file_source_0_0_0, '0', analog_agc_xx_0, '0']
- [blocks_float_to_short_1, '0', blocks_burst_tagger_1, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_keep_one_in_n_0, '0', tpms_poore_decoder_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_short_1, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_threshold_ff_0_0, '0']
- [limesdr_source_0, '0', analog_agc_xx_0, '0']
- [tpms_poore_decoder_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
