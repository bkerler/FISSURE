options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: FM_Radio_FM_LimeSDR_From_File
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '""'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Transmits FM data from a file on a loop."'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '"Yes"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 108e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '60'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '480000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: float
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(tx_gain)
    gain_dB_ch1: int(tx_gain)
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: tx_frequency
    samp_rate: sample_rate
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 48000/sample_rate
    type: float
  states: {}

connections:
- [analog_wfm_tx_0, '0', limesdr_sink_0, '0']
- [blocks_file_source_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
