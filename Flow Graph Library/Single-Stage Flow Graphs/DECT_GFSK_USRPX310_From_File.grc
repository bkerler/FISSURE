options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: DECT_GFSK_USRPX310_From_File
    output_language: python
  states: {}

blocks:
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Attack Recordings/DECT_Data"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: notes
  id: variable
  parameters:
    value: '"Modulates a previously-recorded DECT packet."'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3.456e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 1926.720e6
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 1921.536e6
  states: {state: disabled}
- name: tx_frequency
  id: variable
  parameters:
    value: 1923.264e6
  states: {state: disabled}
- name: tx_frequency
  id: variable
  parameters:
    value: 1924.992e6
  states: {state: disabled}
- name: tx_frequency
  id: variable
  parameters:
    value: 1928.448e6
  states: {state: disabled}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1000000'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filepath
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '3'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: tx_usrp_gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_delay_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_mod_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
