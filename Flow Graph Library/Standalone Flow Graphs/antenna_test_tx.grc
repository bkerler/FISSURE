options:
  parameters:
    generate_options: qt_gui
    id: antenna_test_tx
    output_language: python
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '70'
    value: '70'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tx_freq
  id: variable_qtgui_chooser
  parameters:
    label0: '900'
    label1: '2400'
    label2: '5800'
    num_opts: '3'
    option0: '900000000'
    option1: '2400000000'
    option2: '5800000000'
    type: int
    value: '900000000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 100e6
    step: 10e6
    stop: 6000e6
    value: 900e6
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    samp_rate: 1e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_1_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
