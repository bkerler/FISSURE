options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: j2497_mod_fl2k
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '7777777'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '127'
    type: float
  states: {}
- name: j2497_encoder_0
  id: j2497_encoder
  parameters:
    data: '00'
    interval: '1'
    mid: 0A
    sample_rate: samp_rate
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '31337'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: run 'fl2k_tcp -a <this ip> -s 7777777 -p 31337 -b 8'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_char_0, '0', network_tcp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_char_0, '0']
- [j2497_encoder_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
