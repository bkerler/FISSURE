options:
  parameters:
    generate_options: qt_gui
    id: antenna_test_rx
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    label0: '900'
    label1: '2400'
    label2: '5800'
    num_opts: '3'
    option0: '900000000'
    option1: '2400000000'
    option2: '5800000000'
    type: int
    value: '900000000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 100e6
    step: 10e6
    stop: 6000e6
    value: 900e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    ymin: '-90'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '70'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
