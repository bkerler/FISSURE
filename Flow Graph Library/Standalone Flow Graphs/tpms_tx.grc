options:
  parameters:
    generate_options: qt_gui
    id: tpms_tx
    output_language: python
    title: tpms_tx
  states: {}

blocks:
- name: battery_status
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: configuration
  id: variable
  parameters:
    value: '1'
  states: {}
- name: counter
  id: variable
  parameters:
    value: '"00"'
  states: {}
- name: repetition_interval
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: self_test
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: sensor_id
  id: variable
  parameters:
    value: '"528A510"'
  states: {}
- name: string_variables
  id: variable
  parameters:
    value: '["sensor_id","battery_status","counter","unknown1","unknown2","self_test"]'
  states: {state: disabled}
- name: tire_pressure_psi
  id: variable
  parameters:
    value: '5'
  states: {}
- name: tire_temperature_c
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 314.96e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '90'
    value: '40'
  states: {}
- name: unknown1
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: unknown2
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '15800'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 100*8*20
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.65'
    samples_per_symbol: '100'
    sensitivity: '0.25'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: tx_freq
    gain0: '10'
    if_gain0: tx_gain
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '80000'
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '80000'
    srate: '1'
    type: complex
  states: {}
- name: tpms_poore_message_generator_pdu_0
  id: tpms_poore_message_generator_pdu
  parameters:
    battery_status: battery_status
    configuration: configuration
    counter: counter
    repetition_interval: repetition_interval
    self_test: self_test
    sensor_id: sensor_id
    tire_pressure: tire_pressure_psi
    tire_temp: tire_temperature_c
    unknown1: unknown1
    unknown2: unknown2
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: sample_rate
    sd_spec0: '"A:A"'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', osmosdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [tpms_poore_message_generator_pdu_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
