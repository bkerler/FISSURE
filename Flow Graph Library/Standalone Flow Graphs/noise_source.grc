options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: noise_source
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: 50e6
    step: 1e6
    stop: 6000e6
    value: 2400e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: sample_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: gain
    freq0: frequency
    gain0: '10'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: frequency
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: frequency
    clock_rate: '0.0'
    dev_addr: '"addr=" + ip_address'
    dev_args: '""'
    gain0: gain
    len_tag_name: ''
    samp_rate: sample_rate
    sd_spec0: '"A:0"'
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_noise_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_noise_source_x_0, '0', uhd_usrp_sink_0_0, '0']
- [analog_sig_source_x_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
