options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: waterfall_rtl2832u
    output_language: python
  states: {}

blocks:
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    outputmsgname: value
    showports: 'False'
    start: '50'
    step: '.1'
    stop: '6000'
    value: '915'
  states: {}
- name: rx_rtl_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["0.5 MS/s", "1 MS/s", "2 MS/s"]'
    num_opts: '0'
    options: '[0.5, 1e6, 2e6]'
    type: real
    value: 1e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,6,4
    showports: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: rx_rtl_gain
    freq0: rx_frequency*1e6
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
