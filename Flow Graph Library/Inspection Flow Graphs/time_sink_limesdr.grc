options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: time_sink_limesdr
    output_language: python
  states: {}

blocks:
- name: decimation
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: '  Keep 1 in N'
    labels: '["1","10","100","1000"]'
    num_opts: '0'
    options: '[1,10,100,1000]'
    type: int
    value: '1'
  states: {}
- name: rx_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,4
    label: ' Freq. (MHz):'
    outputmsgname: value
    showports: 'False'
    start: '50'
    step: '.1'
    stop: '6000'
    value: '2412'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: '              Gain:'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Sample Rate
    labels: '["1 MS/s", "5 MS/s", "10 MS/s", "20 MS/s"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: int(rx_gain)
    gain_dB_ch1: '50'
    oversample: '0'
    rf_freq: rx_frequency*1e6
    samp_rate: sample_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 14,0,10,4
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,10,4
    label1: ''
    label2: ''
    size: '100000'
    srate: sample_rate/decimation
    tr_level: '0.005'
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0, '0']
- [limesdr_source_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-207-gcaa7e7f1
